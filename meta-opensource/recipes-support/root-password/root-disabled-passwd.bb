require root-passwd.inc

ROOT_SHELL = "/usr/bin/false"
ROOT_PASSWD = "*"
