require root-passwd.inc

# password is root
ROOT_SHELL ??= "/usr/bin/zsh"
ROOT_PASSWD = "\$6\$SNnaFOPQ0e7d0fGI\$jsq3EKXHKbUbOnqZ.TCdHky8QmqKOtyPeuLUKWFa8LEUbXoTb1FKJ6GKYqJ.n2I7.we01xwflcPYLAzwzC91R0"
