require root-passwd.inc

ROOT_SHELL ??= "/usr/bin/zsh"
ROOT_PASSWD = ""
